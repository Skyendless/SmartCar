# Keil uVision project STM32F4_XWH.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4_XWH
  c flags: Optim=1 wLevel=2
  c define: STM32F4xx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Hardware;..\Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c delay.c include.h
  group Hardware
    ../Hardware/: led.c Key.c usart.c Lcd_9341.c Tim4_Sys.c CCD_Init.c pwm_out.c Control.c Touch.c Encode.c
  group Lib
    ../Libraries/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_exti.c
  group Readme
    ../User/: Readme.txt
